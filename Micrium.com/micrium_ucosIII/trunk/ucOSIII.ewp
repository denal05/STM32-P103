# IAR project ucOSIII.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103xB ST STM32F103xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD
  ICCARM.PreInclude: Config\stm32f10x_conf.h
  ICCARM.CCIncludePath2: Config; APP; PubLib\inc; target; uCOS-III\Source; uCOS-III\Ports; uC-CPU\ARM-Cortex-M3; uC-CPU\Cfg; uC-CPU; uC-LIB\Cfg; uC-LIB\Ports; uC-LIB; uCOS-III\Cfg; PubLib\CMSIS\CM3\DeviceSupport\ST\STM32F10x
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ucOSIII.srec
  ILINK.IlinkOutputFile: ucOSIII.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\ST\stm32f103xE.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group APP
    APP/: app.c app_cfg.h Drivers.h Lcd_HX8312.c Spi.c Spi.h SpiTouch.c SpiTouch.h stm32f10x_it.c Uart.c Uart.h
  group Config
    Config/: hw_types.h includes.h stm32f10x_conf.h
  group PubLib
    PubLib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/iar/: startup_stm32f10x_hd.s
    PubLib/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group PubLib/Inc
    PubLib/inc/: misc.h stm32f10x_adc.h stm32f10x_bkp.h stm32f10x_can.h stm32f10x_cec.h stm32f10x_crc.h stm32f10x_dac.h stm32f10x_dbgmcu.h stm32f10x_dma.h stm32f10x_exti.h stm32f10x_flash.h stm32f10x_fsmc.h stm32f10x_gpio.h stm32f10x_i2c.h stm32f10x_iwdg.h stm32f10x_pwr.h stm32f10x_rcc.h stm32f10x_rtc.h stm32f10x_sdio.h stm32f10x_spi.h stm32f10x_tim.h stm32f10x_usart.h stm32f10x_wwdg.h
  group PubLib/Src
    PubLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Target
    Target/: bsp.c bsp.h
  group uC-CPU
    uC-CPU/: cpu_core.c cpu_core.h cpu_def.h
  group uC-CPU/Cfg
    uC-CPU/Cfg/: cpu_cfg.h
  group uC-CPU/Cortex-M3
    uC-CPU/ARM-Cortex-M3/: cpu.h cpu_a.asm cpu_c.c
  group uC-LIB
    uC-LIB/: lib_ascii.c lib_ascii.h lib_def.h lib_math.c lib_math.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group uC-LIB/CFG
    uC-LIB/Cfg/: lib_cfg.h
  group uC-LIB/Port
    uC-LIB/Ports/: lib_mem_a.asm
  group uC-OS/Cfg
    uCOS-III/Cfg/: os_app_hooks.c os_app_hooks.h os_cfg.h os_cfg_app.h
  group uC-OS/Ports
    uCOS-III/Ports/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_type.h
  group uC-OS/Source
    uCOS-III/Source/: os.h os_cfg_app.c os_core.c os_dbg.c os_flag.c os_int.c os_mem.c os_msg.c os_mutex.c os_pend_multi.c os_prio.c os_q.c os_sem.c os_stat.c os_task.c os_tick.c os_time.c os_tmr.c os_var.c
