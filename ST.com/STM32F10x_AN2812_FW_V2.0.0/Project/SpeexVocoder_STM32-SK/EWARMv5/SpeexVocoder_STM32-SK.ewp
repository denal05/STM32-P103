# IAR project SpeexVocoder_STM32-SK.ewp, settings and files
configuration SpeexVocoder_STM32-SK (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STM32F10xxB ST STM32F10xxB
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; HAVE_CONFIG_H
  ICCARM.CCIncludePath2: ..\inc; ..\..\..\Libraries\STM32F10x_StdPeriph_Driver\inc; ..\..\..\Libraries\STM32F10x_Speex_Lib\include; ..\..\..\Libraries\STM32F10x_Speex_Lib\libspeex; ..\..\..\Libraries\STM32F10x_Speex_Lib\STM32; ..\..\..\Libraries\STM32F10x_Speex_Lib\STM32\include; ..\..\..\Libraries\STM32F10x_Speex_Lib\STM32\libspeex; ..\..\..\Libraries\STM32F10x_Speex_Lib\STM32\libspeex\iar; ..\..\..\Libraries\CMSIS\Core\CM3
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 2
  OBJCOPY.OOCOutputFile: SpeexVocoder_IAR.srec
  ILINK.IlinkOutputFile: SpeexVocoder_STM32-SK.out
  ILINK.IlinkIcfFile: STM32F10x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group CMSIS
    ../../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group EWARMv5
    ../../../Libraries/CMSIS/Core/CM3/startup/iar/: startup_stm32f10x_hd.s startup_stm32f10x_ld.s startup_stm32f10x_md.s
  group libspeex
    ../../../Libraries/STM32F10x_Speex_Lib/libspeex/: bits.c buffer.c exc_10_32_table.c gain_table_lbr.c high_lsp_tables.c lpc.c lsp.c lsp_tables_nb.c speex.c speex_callbacks.c speex_header.c window.c
    ../../../Libraries/STM32F10x_Speex_Lib/STM32/libspeex/: cb_search.c filters.c ltp.c modes.c nb_celp.c quant_lsp.c vq.c
    ../../../Libraries/STM32F10x_Speex_Lib/STM32/libspeex/iar/: filters_cortexM3.s ltp_cortexM3.s vq_cortexm3.s
  group StdPeriph_Driver
    ../../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_tim.c
  group User
    ../src/: drv_hd44780.c drv_hd44780_l.c main.c stm32f10x_it.c vocoder.c
