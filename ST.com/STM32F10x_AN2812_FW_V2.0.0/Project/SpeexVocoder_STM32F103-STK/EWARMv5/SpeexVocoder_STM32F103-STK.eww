<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\SpeexVocoder_STM32F103-STK.ewp</path>
  </project>
  <batchBuild/>
</workspace>


